FILESEXTRAPATHS:prepend := "${THISDIR}:"

require gcc-arm-none-eabi_11.inc
