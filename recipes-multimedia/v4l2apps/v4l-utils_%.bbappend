# disable tracer which causes build-time error
EXTRA_OECONF += "--disable-v4l2-tracer"
