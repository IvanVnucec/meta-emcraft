# Copyright (C) 2023 Emcraft Systems

STM32MP_SOURCE_SELECTION = "github"
SRC_URI:class-devupstream = "git://github.com/IvanVnucec/optee-stm32mp.git;protocol=https;branch=linux-stm32mp1-4.1.0"

SRCREV:class-devupstream = "${AUTOREV}"
