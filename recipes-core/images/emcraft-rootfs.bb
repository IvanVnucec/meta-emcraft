# Copyrigh (C) 2021 Emcraft Systems

require recipes-st/images/st-image-weston.bb

MACHINE_EXTRA_RDEPENDS += "kernel-module-rpmsg-tty"
